options:
  parameters:
    author: cbro
    generate_options: qt_gui
    id: pll_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filter_2ndorder_0
  id: variables_loop_filter_2ndorder
  parameters:
    damping: '0.707'
    natural_freq: '800'
    samp_rate: samp_rate
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    orient: Qt.Horizontal
    start: '-20e3'
    step: '100'
    stop: 20e3
    value: '11000'
  states: {}
- name: modulation_coeff
  id: variable_qtgui_range
  parameters:
    label: Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: sweep_range
  id: variable_qtgui_range
  parameters:
    label: Sweep Range (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: 1e3
    stop: 50e3
    value: '8000'
  states: {}
- name: sweep_rate
  id: variable_qtgui_range
  parameters:
    label: Sweep rate (Hz/s)
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: 50e3
    value: '2000'
  states: {}
- name: variables_loop_filter_2ndorder_0_0
  id: variables_loop_filter_2ndorder
  parameters:
    damping: '0.707'
    natural_freq: '800'
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(-snr/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: modulation_coeff
    freq: subcarrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2_1
  id: analog_sig_source_x
  parameters:
    amp: 2*3.14159265359*sweep_range
    freq: 0 if sweep_range == 0 else sweep_rate/sweep_range
    offset: 2*3.14159265359*frequency
    phase: '-3.14159265359'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/6.283185307179586
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '1'
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '0'
    coefficients: filter_2ndorder_0
    freq_central: '15000'
    samp_rate: samp_rate
  states: {}
- name: ecss_signal_search_goertzel_0
  id: ecss_signal_search_goertzel
  parameters:
    average: 'True'
    bandwidth: '3000'
    enable: 'True'
    freq_central: '15000'
    freq_cutoff: '100'
    samp_rate: samp_rate
    threshold: '10'
  states: {}
- name: ecss_threshhold_to_message_0
  id: ecss_threshhold_to_message
  parameters:
    init_state: 'False'
    lower_message: pmt.intern("UNLOCK")
    lower_threshhold: '0.5'
    upper_message: pmt.intern("LOCK")
    upper_threshhold: '0.8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Input
    label2: PLL Output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
    ymin: '-90'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: Baseband
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: PLL Output
    label2: Input Oscillator
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Frequency
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: IQ
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.0196'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_2_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_2_1, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_2_1, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_1, '0', ecss_signal_search_goertzel_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_2, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_float_2, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_float_2, '1', qtgui_time_sink_x_0_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_throttle_0_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [ecss_pll_0, '0', blocks_complex_to_float_2, '0']
- [ecss_pll_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_pll_0, '0', qtgui_time_sink_x_0, '0']
- [ecss_pll_0, '1', qtgui_time_sink_x_0_0, '0']
- [ecss_signal_search_goertzel_0, '0', ecss_pll_0, '0']
- [ecss_threshhold_to_message_0, threshhold_msg, blocks_message_debug_0, print]
- [ecss_threshhold_to_message_0, threshhold_msg, ecss_signal_search_goertzel_0, lock_in]
- [single_pole_iir_filter_xx_0, '0', ecss_threshhold_to_message_0, '0']

metadata:
  file_format: 1
