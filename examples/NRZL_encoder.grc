options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: NRZL_encoder
    output_language: python
    title: NRZ-L Encoder
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: bit_rate/8
    type: byte
  states: {}
- name: ecss_nrzl_encoder_0
  id: ecss_nrzl_encoder
  parameters:
    bit_rate: bit_rate
    samp_rate: samp_rate
  states: {}
- name: ecss_nrzl_encoder_subcarrier_1
  id: ecss_nrzl_encoder_subcarrier
  parameters:
    bit_rate: bit_rate
    freq_sub: '16000.0'
    samp_rate: samp_rate
    sine: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: 0,0,1,1
    legend: 'False'
    name: '"NRZ-L Encoder"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: 0,1,1,1
    legend: 'False'
    name: '"NRZ-L Encoder with Sub-carrier"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ecss_nrzl_encoder_0, '0']
- [blocks_throttle_0, '0', ecss_nrzl_encoder_subcarrier_1, '0']
- [ecss_nrzl_encoder_0, '0', qtgui_freq_sink_x_0, '0']
- [ecss_nrzl_encoder_subcarrier_1, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
