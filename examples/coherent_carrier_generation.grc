options:
  parameters:
    author: Stefano Speretta
    generate_options: qt_gui
    id: coherent_carrier_generation
    output_language: python
    title: Coherent Carrier Generation
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    label: Signal Level
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '0.01'
  states: {}
- name: coherency
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,1,1,1
    label: Coherency
    label0: Open Loop
    label1: Coherent
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Center frequency (Hz)
    start: '-20e3'
    step: '100'
    stop: 20e3
    value: '11000'
  states: {}
- name: loop_filter_2nd_order
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '800'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.6'
  states: {}
- name: loop_filter_3rd_order
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '500'
    order: 3rd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.0674'
  states: {}
- name: loop_order_chooser
  id: variable_qtgui_chooser
  parameters:
    label: PLL Loop Order
    label0: Second Order
    label1: Third Order
    num_opts: '2'
    option0: loop_filter_2nd_order
    option1: loop_filter_3rd_order
    orient: Qt.QHBoxLayout
    type: raw
    value: loop_filter_2nd_order
    widget: radio_buttons
  states: {}
- name: modulation_coeff_down
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Downlink Modulation Coefficent
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: modulation_coeff_up
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Uplink Modulation Coefficent
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: SNR (dB)
    start: '-20'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: sweep_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Sweep Range (Hz)
    start: '0'
    step: 1e3
    stop: 1E6
    value: '100000'
  states: {}
- name: sweep_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1, 1, 1
    label: Sweep rate (Hz/s)
    start: '0'
    step: '100'
    stop: 50e3
    value: '4000'
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sweep_range/samp_rate*3.14
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(-snr/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: sweep_rate/sweep_range/2
    offset: '-1'
    phase: '-3.14'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: modulation_coeff_down
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.5'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ecss_agc_xx_0
  id: ecss_agc_xx
  parameters:
    initial_gain: '1.0'
    maximum_gain: '65536.0'
    reference: '1.0'
    samp_rate: samp_rate
    settling_time: '10.0'
    type: float
  states: {state: bypassed}
- name: ecss_coherent_phase_modulator_0
  id: ecss_coherent_phase_modulator
  parameters:
    N: '38'
  states: {}
- name: ecss_gain_phase_accumulator_0
  id: ecss_gain_phase_accumulator
  parameters:
    downlink: 440*coherency
    rst: 'False'
    uplink: '221'
  states: {}
- name: ecss_phase_converter_0
  id: ecss_phase_converter
  parameters:
    N: '38'
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '0'
    coefficients: loop_order_chooser
    freq_central: '15000'
    params_loop_detector: '[0.0001, 0.5, 0.8]'
    samp_rate: samp_rate
    sel_loop_detector: int
  states: {}
- name: ecss_signal_search_goertzel_0
  id: ecss_signal_search_goertzel
  parameters:
    average: 'False'
    bandwidth: '3000'
    enable: 'True'
    freq_central: '15000'
    freq_cutoff: '3000'
    samp_rate: samp_rate
    threshold: '10'
  states: {}
- name: ecss_threshold_to_message_0
  id: ecss_threshold_to_message
  parameters:
    init_state: 'False'
    lower_message: pmt.cons(pmt.intern("LOCK"), pmt.from_bool(False))
    lower_threshold: '0.5'
    upper_message: pmt.cons(pmt.intern("LOCK"), pmt.from_bool(True))
    upper_threshold: '0.8'
  states: {}
- name: flaress_add_0
  id: flaress_add
  parameters:
    num_inputs: '2'
    type: s64
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,7,1
    label1: Input
    label2: Output
    nconnections: '2'
    type: complex
    ymax: '20'
    ymin: '-90'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    name: Lock
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.0196'
    type: float
  states: {}

connections:
- [analog_agc_xx_1, '0', ecss_signal_search_goertzel_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_1, '0']
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_xx_1, '0', analog_agc_xx_1, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_2, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_float_2, '1', ecss_agc_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', ecss_phase_converter_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rms_xx_0, '0', ecss_threshold_to_message_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_1, '1']
- [ecss_agc_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [ecss_coherent_phase_modulator_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_gain_phase_accumulator_0, '0', flaress_add_0, '0']
- [ecss_phase_converter_0, '0', flaress_add_0, '1']
- [ecss_pll_0, '0', blocks_complex_to_float_2, '0']
- [ecss_pll_0, '1', blocks_null_sink_0_0, '0']
- [ecss_pll_0, '2', blocks_null_sink_0, '0']
- [ecss_pll_0, '3', ecss_gain_phase_accumulator_0, '0']
- [ecss_pll_0, lock_out_msg, blocks_message_debug_0, print]
- [ecss_pll_0, lock_out_msg, ecss_signal_search_goertzel_0, lock_in]
- [ecss_signal_search_goertzel_0, '0', ecss_pll_0, '0']
- [flaress_add_0, '0', ecss_coherent_phase_modulator_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_rms_xx_0, '0']

metadata:
  file_format: 1
