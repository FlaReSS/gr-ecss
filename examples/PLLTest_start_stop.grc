options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: PLLTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: loop_filter_0
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '100'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 0.707 * 10**(-SNR_dB/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.2'
    offset: '1'
    phase: '3.14'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("pll")
    nsamps: samp_rate*7
    type: complex
    value: pmt.intern("stop")
  states: {}
- name: blocks_tags_strobe_1
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("pll")
    nsamps: samp_rate*15
    type: complex
    value: pmt.intern("start")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 6.28*1e3
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '1000.0'
    coefficients: loop_filter_0
    freq_central: 1e3
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    label1: PLL Input
    label2: PLL Output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Carrier Frequency
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Phase error
    size: '1024'
    srate: samp_rate
    type: float
    ymax: samp_rate
    ymin: '-samp_rate'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '2']
- [blocks_tags_strobe_1, '0', blocks_add_xx_0, '3']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', ecss_pll_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_c_0, '0', blocks_add_xx_0, '0']
- [ecss_pll_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_pll_0, '1', qtgui_number_sink_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
