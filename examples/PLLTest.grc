options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: PLLTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: loop_filter_0
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '100'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 0.707 * 10**(-SNR_dB/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.5'
    freq: '0.10'
    offset: '0.25'
    phase: '3.14'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ubuntu/Desktop/frequency_dump2
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/ubuntu/Desktop/outofpll2
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/ubuntu/Desktop/frequencies2
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 5*samp_rate
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 6.28*1e3
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '4000'
    coefficients: loop_filter_0
    freq_central: '0'
    samp_rate: samp_rate
    test: '250'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    label1: PLL Input
    label2: PLL Output
    nconnections: '2'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Carrier Frequency
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Phase error
    name: '"Phase error"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: samp_rate
    ymin: '-samp_rate'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_file_sink_2, '0']
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_head_0, '0', blocks_tag_debug_0, '0']
- [blocks_head_0, '0', ecss_pll_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [blocks_vco_c_0, '0', blocks_add_xx_0, '0']
- [ecss_pll_0, '0', blocks_file_sink_1, '0']
- [ecss_pll_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_pll_0, '1', blocks_file_sink_0, '0']
- [ecss_pll_0, '1', qtgui_number_sink_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
