options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: PLLTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: frequency
    orient: Qt.Horizontal
    start: '-3000'
    step: '100'
    stop: '3000'
    value: 1e3
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '80'
    value: '10'
  states: {}
- name: variables_loop_filter_0
  id: variables_loop_filter
  parameters:
    damping_2: '0.707'
    damping_3: '0.707'
    epsilon: '0'
    index_m_3: '4'
    natural_freq_2: '10'
    natural_freq_3: '10'
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 0.707 * 10**(-variable_qtgui_range_0_0/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("pll")
    nsamps: samp_rate*5
    type: complex
    value: pmt.intern("reset")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '1000.0'
    coefficients: '[0.00884505, 3.9303e-5]'
    freq_central: 0.8e3
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: samp_rate
    ymin: '-samp_rate'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '2']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', ecss_pll_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [ecss_pll_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_pll_0, '1', qtgui_number_sink_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
