options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: modulatorNRZL
    output_language: python
    title: NRZ-L Modulator
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '800000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: bit_rate/8
    type: byte
  states: {}
- name: ecss_nrzl_encoder_subcarrier_0
  id: ecss_nrzl_encoder_subcarrier
  parameters:
    bit_rate: bit_rate
    freq_sub: '4000.0'
    samp_rate: samp_rate
    sine: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ecss_nrzl_encoder_subcarrier_0, '0']
- [ecss_nrzl_encoder_subcarrier_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
