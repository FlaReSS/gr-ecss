options:
  parameters:
    author: Stefano Speretta
    generate_options: qt_gui
    id: PLL_order_switch
    output_language: python
    title: PLL Order Switch Example
  states: {}

blocks:
- name: filter_2ndorder
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '1800'
    order: 2nd
    samp_rate: samp_rate
    t1: '0.1'
    t2: '0.01'
  states: {}
- name: filter_3rdorder
  id: loop_filter
  parameters:
    damping: '0.707'
    natural_freq: '10'
    order: 3rd
    samp_rate: samp_rate
    t1: '0.01'
    t2: '0.674'
  states: {}
- name: loop_order_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: PLL Loop Order
    label0: Second Order
    label1: Third Order
    num_opts: '2'
    option0: filter_2ndorder
    option1: filter_3rdorder
    orient: Qt.QHBoxLayout
    type: raw
    value: filter_2ndorder
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: frequency
    orient: Qt.Horizontal
    start: '-3000'
    step: '100'
    stop: '3000'
    value: 1.5e3
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: SNR (dB)
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '80'
    value: '10'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 0.707 * 10**(-variable_qtgui_range_0_0/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '10000.0'
    coefficients: loop_order_chooser
    freq_central: 0.8e3
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,3,1
    label1: PLL Input
    label2: PLL Output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 3,0,1,1
    label1: Phase error
    legend: 'False'
    name: Phase error
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Radians
    ymax: '3.2'
    ymin: '-3.2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 3,1,1,1
    legend: 'False'
    name: Frequency
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Hz
    ymax: samp_rate/2
    ymin: '-samp_rate/2'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', ecss_pll_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [ecss_pll_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_pll_0, '1', qtgui_time_sink_x_0_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
