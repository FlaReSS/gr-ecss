options:
  parameters:
    author: Stefano Speretta
    generate_options: qt_gui
    id: subcarrier_generation_with_ranging
    output_language: python
    title: Subcarrier with ranging
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Center frequency (Hz)
    orient: Qt.Horizontal
    start: '-10e3'
    step: '100'
    stop: 10e3
    value: '0'
  states: {}
- name: modulation_coeff
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1.4'
    value: '0'
    widget: counter
  states: {}
- name: modulation_coeff_ranging
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Ranging Modulation Coefficent
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1.4'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '800000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: SNR (dB)
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: Data
    label0: 'No'
    label1: 'Yes'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: variables_loop_filter_2ndorder_0
  id: variables_loop_filter_2ndorder
  parameters:
    damping: '0.707'
    natural_freq: '100'
    samp_rate: samp_rate
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(-snr/10)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_2_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: modulation_coeff
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: modulation_coeff_ranging
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1, 1, 0)
  states: {}
- name: ecss_nrzl_encoder_subcarrier_0_0
  id: ecss_nrzl_encoder_subcarrier
  parameters:
    bit_rate: bit_rate
    freq_sub: '16000.0'
    samp_rate: samp_rate
    sine: 'True'
  states: {}
- name: ecss_nrzl_encoder_subcarrier_0_0_0
  id: ecss_nrzl_encoder_subcarrier
  parameters:
    bit_rate: bit_rate
    freq_sub: '196000.0'
    samp_rate: samp_rate
    sine: 'True'
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '0'
    coefficients: variables_loop_filter_2ndorder_0
    freq_central: '0.0'
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,2,1
    legend: 'False'
    name: IF Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,3,1
    label1: Input
    label2: Output
    name: Baseband
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_throttle_0_0_0_0, '0']
- [analog_const_source_x_0_0_0, '0', ecss_nrzl_encoder_subcarrier_0_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0_0, '0']
- [analog_random_source_x_0_0_0, '0', ecss_nrzl_encoder_subcarrier_0_0_0, '0']
- [analog_sig_source_x_2_1, '0', blocks_throttle_0_0_0_1, '0']
- [blocks_add_xx_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_add_xx_1, '0', ecss_pll_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_selector_0_0, '0', ecss_nrzl_encoder_subcarrier_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_selector_0_0, '1']
- [blocks_throttle_0_0_0_0, '0', blocks_selector_0_0, '0']
- [blocks_throttle_0_0_0_1, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_throttle_0_0_0, '0']
- [ecss_nrzl_encoder_subcarrier_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [ecss_nrzl_encoder_subcarrier_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [ecss_pll_0, '0', blocks_null_sink_0, '0']
- [ecss_pll_0, '1', blocks_null_sink_1, '0']
- [ecss_pll_0, '2', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
