options:
  parameters:
    generate_options: qt_gui
    id: SPLTest
    output_language: python
    title: SPLTest
  states: {}

blocks:
- name: oversampling
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: ecss_spl_decoder_0
  id: ecss_spl_decoder
  parameters:
    oversampling: oversampling
  states: {}
- name: ecss_spl_encoder_0
  id: ecss_spl_encoder
  parameters:
    oversampling: oversampling
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '2.0'
    alpha3: '3.0'
    ctrlpanel: 'True'
    marker1: '0'
    marker2: '0'
    nconnections: '3'
    size: '300'
    srate: samp_rate
    tr_chan: '2'
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_throttle_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_throttle_0, '0', ecss_spl_encoder_0, '0']
- [blocks_throttle_0, '0', fec_ber_bf_0, '0']
- [ecss_spl_decoder_0, '0', blocks_char_to_float_0, '0']
- [ecss_spl_decoder_0, '0', fec_ber_bf_0, '1']
- [ecss_spl_encoder_0, '0', ecss_spl_decoder_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
