options:
  parameters:
    author: stefanosperett
    generate_options: qt_gui
    id: simple_pll
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variables_loop_filter_0
  id: variables_loop_filter
  parameters:
    damping_2: '0.707'
    damping_3: '0.707'
    epsilon: '0'
    index_m_3: '4'
    natural_freq_2: '400'
    natural_freq_3: '10'
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '0.05'
    offset: '-1'
    phase: '3.14'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 20e3
  states: {}
- name: ecss_pll_0
  id: ecss_pll
  parameters:
    N: '38'
    bw: '1000.0'
    coefficients: variables_loop_filter_0
    freq_central: '100'
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    label1: Source
    label2: PLL
    nconnections: '2'
    type: complex
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Frequency"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Phase Error"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: samp_rate
    ymin: '-samp_rate'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_vco_c_0, '0']
- [blocks_vco_c_0, '0', ecss_pll_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_0, '0']
- [ecss_pll_0, '0', qtgui_freq_sink_x_0, '1']
- [ecss_pll_0, '1', qtgui_number_sink_0, '0']
- [ecss_pll_0, '2', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
